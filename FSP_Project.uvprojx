# Keil uVision project FSP_Project.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: R7FA6M3AH Renesas
  pack: Renesas.RA_DFP.5.5.0
  cpu: IRAM(0x1FFE0000,0x020000) IRAM2(0x20000000,0x080000) IROM(0x00000000,0x200000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FSP_Project +hex
  BeforeMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out"""
  AfterMake: cmd /c "start "Renesas" /w cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out"""
  c flags: v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  c include: .\src\easylogger\inc;.\src\LED;.\src\UART;.\src\DEBUG;.\src\app
  asm misc: --via=via/rasc_armasm.via
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x1ffe0000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x80000
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c app_create_thread_entry.c
    ./src/app/: app_led_thread.c app_led_thread.h
    ./src/DEBUG/: debug.c debug.h
    ./src/easylogger/inc/: elog.h elog_cfg.h
    ./src/easylogger/plugins/file/: elog_file.c elog_file.h elog_file_cfg.h elog_file_port.c
    ./src/easylogger/plugins/flash/: elog_flash.c elog_flash.h elog_flash_cfg.h elog_flash_port.c
    ./src/easylogger/port/: elog_port.c
    ./src/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ./src/LED/: bsp_led.c bsp_led.h
    ./src/UART/: bsp_uart.c bsp_uart.h
  group bsp
    ./src/UART/: bsp_uart.c
    ./src/LED/: bsp_led.c
    ./src/easylogger/src/: elog.c elog_utils.c
    ./src/easylogger/port/: elog_port.c
    ./src/DEBUG/: debug.c
  group app
    ./src/app/: app_led_thread.c
software components: Flex Software:RA Configuration 1.0.0
